# Keil uVision project guyan.uvprojx, settings and files
target guyan (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\CORE;..\USER;..\SYSTEM;..\SYSTEM\delay;..\STM32F0xx_FWLib\inc;..\STM32F0xx_FWLib\src;..\HARDWARE\LED;..\HARDWARE\IWDG;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\SYSTEM\sys;..\SYSTEM\USART
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c motor.c spi.c
  group CORE
    ../CORE/: startup_stm32f0xx_ld.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/USART/: USART.c
  group HARDWARE
    ../HARDWARE/IWDG/: IWDG.c
    ../HARDWARE/TIMER/: TIMER.c
    ../HARDWARE/EXTI/: EXTI.c
  group FWLIB
    ../STM32F0xx_FWLib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
